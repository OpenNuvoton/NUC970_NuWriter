# Keil uVision project syslib.uvproj, settings and files
target syslib (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: syslib (library)
  c flags: Optim=1 OneElfS=1
  c include: ..\..\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group src
    ../: wb_aic.c wb_cache.c wb_config.c wb_ebi.c wb_mmu.c wb_timer.c wb_uart.c wb_dcache.s wb_sysctl.s
