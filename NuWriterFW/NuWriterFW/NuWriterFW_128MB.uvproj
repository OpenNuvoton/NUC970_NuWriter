# Keil uVision project NuWriterFW_128MB.uvproj, settings and files
target NuWriterFW (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NuWriterFW_128MB
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\@L.bin"
  AfterMake: header_128MB.bat
  c flags: Optim=3 OneElfS=1
  c define: TURBOWRITER128=1
  c include: .\source;..\SYSLIB\Lib
  memory RVCT1: ROM 0x7f00000 size 0x100000
  memory RVCT6: RAM 0x8000 size 0x80000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\source\scat_c_128.scf
  link misc: --entry 0x07F00040
  group Source
    ./source/: usbd.c standalone.c flash.c sm.c spiflash.c main.c parse.c sd.c sdglue.c filesystem.c exesdramdtb.s wb_init_128.s
    ../SYSLIB/Src/SysLib/obj/: syslib.lib
