# Keil uVision project NuWriterFW_16MB.uvproj, settings and files
target NuWriterFW (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NuWriterFW_16MB
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\@L.bin"
  AfterMake: header_16MB.bat
  c flags: Optim=3 OneElfS=1
  c define: TURBOWRITER16=1
  c include: .\source;..\SYSLIB\Lib
  memory RVCT1: ROM 0xf00000 size 0x100000
  memory RVCT6: RAM 0x8000 size 0x80000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\source\scat_c_16.scf
  link misc: --entry 0x0F00040
  group Source
    ./source/: usbd.c standalone.c flash.c sm.c spiflash.c parse.c sd.c sdglue.c filesystem.c wb_init_16.s main.c exesdramdtb.s
    ../SYSLIB/Src/SysLib/obj/: syslib.lib
